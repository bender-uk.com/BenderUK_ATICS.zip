Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-01-20T10:22:41
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionPort, Port_313513
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcElectricDistributionPoint: NBS_BenderUK_TrnsfrSwtchngEqpmntTSE_ATICS:ATICS-4-80A-DIO, NBS_BenderUK_TrnsfrSwtchngEqpmntTSE_ATICS:ATICS-4-80A-DIO:313513
In: Level 0
Type - Classification: Pr_60_70_48_88 (Uniclass2015); Material: NBS_BenderUK_Green (8), NBS_BenderUK_DisplayScreen (5), NBS_BenderUK_Acrylic_Clear, NBS_BenderUK_DarkGrey, NBS_BenderUK_Grey, NBS_BenderUK_Yellow (3), NBS_BenderUK_Blue (4), NBS_BenderUK_StainlessSteel_Polished
Type - IFC - IfcExportAs: IfcElectricDistributionBoardType; IfcExportType: DISTRIBUTIONBOARD
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_60_70_48_88:Transfer switching equipment (TSE); Color: n/a; Finish: n/a; Material: Polycarbonate; Shape: Other; Size: n/a; WarrantyDescription: Two year; CodePerformance: n/a; Constituents: n/a; Description: Transfer switching device for safety-relevant and medical locations.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: marketing@bender-uk.com; ModelNumber: n/a; ModelReference: ATICS; Name: TransferSwitchingEquipmentTSE_ATICS_ATICS-4-80A-DIO_BenderUK; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_BenderUK_TransferSwitchingEquipmentTSE_ATICS_ATICS-4-80A-DIO; ManufacturerName: Bender UK; ManufacturerURL: www.bender-uk.com; ProductInformation: https://source.thenbs.com/product/-/968ebb4e-27e5-48ca-9e63-a4e8ce6fb8ba/3ee22bbc-30f3-44aa-a30d-be3785818363; Uniclass2015Code: Pr_60_70_48_88; Uniclass2015Title: Transfer switching equipment (TSE); Uniclass2015Version: Products v1.36; Version: 3
Type - NBS_Data - Standards: To DIN VDE 0100-710, DIN VDE 0100-718, ÖVE/ÖNORM E 8007, IEC 60364-7-710, DIN EN 61508-1, IEC 61508-1, DIN EN 61508-2, IEC 61508-2, DIN EN 61508-3, IEC 61508-3, DIN EN 60947-6-1, IEC 60947-6-1; MethodOfControllingTransfer: Automatic; OperatingSequence: I-O-II; RatedOperationalVoltageUe: 400 V; RatedInsulationVoltageUi: 400 V; RatedOperationalCurrentIe: 80 A; RatedOperationalFrequency: 50 Hz, 60 Hz; NumberOfPolesInformation: Four; Terminals: Screw-type terminals; ControlsType: Integral to switch; ControlsDisplayType: Liquid crystal display (LCD); ControlsIlluminatedDisplayToIndicateTheFollowingConditions: Line 1: Measured values of mains voltage and frequency; Switch position of the automatic transfer switching device; Line 2: Measured values of mains voltage and frequency; Display of the load in the IT system in %; ControlsUser-adjustableFunctions: Changeover; Voltage; Current; Relay; Digital input; Data logger; Language; Interface; Clock; Password; ControlsFeatures: Autom. changeover test; Manual changeover test; Last changeover test; Generator test; Test communication; EnclosureIngressProtectionMinimum: To DIN EN 60529, IP40; EnclosureMaterial: Polycarbonate; EnclosureColour: Yellow; CountryOfProductManufacture: Germany; Material: Polycarbonate; Recyclability: Can be returned to manufacturer for disposal under WEEE regulations; Accessories: ATICS-BP-4-80A-SET Bypass switch set
DistributionPointFunction: DISTRIBUTIONBOARD
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
